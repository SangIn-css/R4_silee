<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\R4_silee.ewp</path>
  </project>
  <batchBuild />
</workspace>
